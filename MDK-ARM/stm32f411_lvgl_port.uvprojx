# Keil uVision project stm32f411_lvgl_port.uvprojx, settings and files
target stm32f411_lvgl_port (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: stm32f411_lvgl_port +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE,LV_CONF_INCLUDE_SIMPLE
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Src/SSD1306;../middleware;../middleware/lvgl;../middleware/lvgl/src;../Inc/lvgl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/SSD1306
    ../Src/SSD1306/: SSD1306.c
  group lvgl_porting
    ../Src/lvgl/: lv_port_disp.c lv_port_fs.c lv_port_indev.c
  group lvgl_src
    ../middleware/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../middleware/lvgl/src/draw/: lv_draw_arc.c lv_draw_blend.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../middleware/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../middleware/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../middleware/lvgl/src/misc/: lv_anim.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../middleware/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
    ../middleware/lvgl/src/extra/: lv_extra.c
    ../middleware/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../middleware/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../middleware/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../middleware/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../middleware/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../middleware/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../middleware/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../middleware/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../middleware/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../middleware/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../middleware/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../middleware/lvgl/src/extra/widgets/led/: lv_led.c
    ../middleware/lvgl/src/extra/widgets/list/: lv_list.c
    ../middleware/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../middleware/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../middleware/lvgl/src/extra/widgets/span/: lv_span.c
    ../middleware/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../middleware/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../middleware/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../middleware/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../middleware/lvgl/src/extra/widgets/win/: lv_win.c
software components: CMSIS:CORE 5.1.2
